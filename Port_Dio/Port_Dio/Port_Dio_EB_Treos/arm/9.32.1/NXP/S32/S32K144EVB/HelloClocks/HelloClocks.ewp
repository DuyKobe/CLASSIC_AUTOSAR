# IAR project HelloClocks.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HelloClocks.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application; ..\EB_Genarate\include; ..\Plug-in\Base_TS_T40D2M10I5R0\include; ..\Plug-in\Det_TS_T40D2M10I5R0\include; ..\Plug-in\Dio_TS_T40D2M10I5R0\include; ..\Plug-in\Port_TS_T40D2M10I5R0\include; ..\Plug-in\Rte_TS_T40D2M10I5R0\include
  ILINK.IlinkIcfFile: ../config/S32K144_ram.icf
  group Application
    Application/: clocks_and_modes.c main.c
  group Application/EB_Generate
    ../Plug-in/Det_TS_T40D2M10I5R0/src/: Det.c
    ../Plug-in/Dio_TS_T40D2M10I5R0/src/: Dio.c Dio_Gpio.c
    ../EB_Genarate/src/: Dio_Cfg.c Port_Cfg.c Port_PBcfg.c
    ../Plug-in/Port_TS_T40D2M10I5R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
    ../Plug-in/Rte_TS_T40D2M10I5R0/src/: SchM_Dio.c SchM_Port.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
